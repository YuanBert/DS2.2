<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DSv2.2Pro.ewp</path>
  </project>
  <batchBuild />
</workspace>
